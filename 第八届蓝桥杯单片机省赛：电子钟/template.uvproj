# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ds18b20;.\ds1302
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./ds1302/: ds1302.c
    ./ds18b20/: onewire.c
